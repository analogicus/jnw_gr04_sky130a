*TB_SUN_TR_SKY130NM/TB_NCM
*----------------------------------------------------------------
* Include
*----------------------------------------------------------------
#ifdef Lay
.include ../../../work/lpe/Opamp_test_lpe.spi
#else
.include ../../../work/xsch/Opamp_test.spice
#endif

*-----------------------------------------------------------------
* OPTIONS
*-----------------------------------------------------------------
.option TNOM=27 GMIN=1e-15 reltol=1e-3

*-----------------------------------------------------------------
* DUT (Device Under Test)
*-----------------------------------------------------------------
.include ../xdut.spi

*-----------------------------------------------------------------
* VOLTAGE SUPPLIES
*-----------------------------------------------------------------
VDD VDD 0 1.8V
VSS VSS 0 0V

*-----------------------------------------------------------------
* INPUT SIGNALS (Differential AC Test)
*-----------------------------------------------------------------
VIN VIN 0 sin(0 30m 1Meg 0 0 0)
* 1 MHz sine wave, 30mV amplitude
VIP VIP 0 sin(0 30m 1Meg 0 0 180)
* 1 MHz sine wave, 30mV amplitude, 180° phase shift

*----------------------------------------------------------------
* PROBE
*----------------------------------------------------------------
.save all
.save V(Vo) V(VIP) V(VIN)
.save i(Vo) i(VIP) i(VIN)
.save V(VDD) V(VSS)
.save i(VDD) i(VSS)
.option savecurrents

*----------------------------------------------------------------
* NGSPICE control
*----------------------------------------------------------------
.control
set num_threads=8
set color0=white
set color1=black
unset askquit

* Perform Transient Analysis
tran 1n 10u

write

quit

.endc

.end
