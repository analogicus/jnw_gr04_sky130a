** sch_path: design/JNW_GR04_SKY130A/Opamp_TB.sch
**.subckt Opamp_TB
x1 net1 net2 net3 GND GND Opamp
V1 net1 GND 3
**.ends
.GLOBAL GND
.end
