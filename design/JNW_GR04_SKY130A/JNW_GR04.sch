v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 560 -820 1240 -820 {lab=VDD_1V8}
N 610 -750 630 -750 {lab=VDD_1V8}
N 610 -780 610 -750 {lab=VDD_1V8}
N 610 -780 630 -780 {lab=VDD_1V8}
N 630 -820 630 -780 {lab=VDD_1V8}
N 750 -750 770 -750 {lab=VDD_1V8}
N 770 -780 770 -750 {lab=VDD_1V8}
N 750 -780 770 -780 {lab=VDD_1V8}
N 750 -820 750 -780 {lab=VDD_1V8}
N 670 -750 710 -750 {lab=#net1}
N 630 -650 630 -590 {lab=Vin}
N 750 -500 750 -480 {lab=VD2_out}
N 750 -420 750 -390 {lab=VSS}
N 630 -590 630 -480 {lab=Vin}
N 750 -650 750 -580 {lab=VD1_out}
N 670 -450 690 -450 {lab=VSS}
N 690 -450 710 -450 {lab=VSS}
N 690 -450 690 -390 {lab=VSS}
N 690 -390 750 -390 {lab=VSS}
N 630 -390 690 -390 {lab=VSS}
N 630 -420 630 -390 {lab=VSS}
N 770 -540 790 -540 {lab=VSS}
N 790 -540 790 -390 {lab=VSS}
N 750 -390 790 -390 {lab=VSS}
N 750 -590 850 -590 {lab=VD1_out}
N 630 -620 850 -620 {lab=Vin}
N 920 -820 920 -730 {lab=VDD_1V8}
N 920 -550 920 -390 {lab=VSS}
N 790 -390 920 -390 {lab=VSS}
N 920 -390 1030 -390 {lab=VSS}
N 1080 -520 1110 -520 {lab=Vo}
N 1220 -490 1240 -490 {lab=VSS}
N 1240 -520 1240 -490 {lab=VSS}
N 1220 -520 1240 -520 {lab=VSS}
N 1030 -520 1080 -520 {lab=Vo}
N 1220 -750 1240 -750 {lab=VDD_1V8}
N 1240 -780 1240 -750 {lab=VDD_1V8}
N 1220 -780 1240 -780 {lab=VDD_1V8}
N 1220 -650 1220 -550 {lab=#net1}
N 1220 -820 1220 -780 {lab=VDD_1V8}
N 1220 -490 1220 -390 {lab=VSS}
N 1030 -390 1150 -390 {lab=VSS}
N 1090 -750 1110 -750 {lab=#net1}
N 1370 -750 1390 -750 {lab=VDD_1V8}
N 1390 -780 1390 -750 {lab=VDD_1V8}
N 1370 -780 1390 -780 {lab=VDD_1V8}
N 1370 -820 1370 -780 {lab=VDD_1V8}
N 1310 -820 1370 -820 {lab=VDD_1V8}
N 1310 -750 1330 -750 {lab=#net1}
N 1370 -720 1370 -670 {lab=I_PTAT}
N 560 -390 630 -390 {lab=VSS}
N 1090 -750 1090 -700 {lab=#net1}
N 690 -750 690 -690 {lab=#net1}
N 920 -730 920 -660 {lab=VDD_1V8}
N 1310 -750 1310 -690 {lab=#net1}
N 1090 -700 1090 -690 {lab=#net1}
N 750 -720 750 -650 {lab=VD1_out}
N 630 -720 630 -650 {lab=Vin}
N 1370 -670 1370 -660 {lab=I_PTAT}
N 690 -690 1240 -690 {lab=#net1}
N 1020 -520 1030 -520 {lab=Vo}
N 1020 -600 1020 -520 {lab=Vo}
N 1240 -690 1310 -690 {lab=#net1}
N 1110 -750 1180 -750 {lab=#net1}
N 1110 -520 1180 -520 {lab=Vo}
N 1150 -390 1220 -390 {lab=VSS}
N 1240 -820 1310 -820 {lab=VDD_1V8}
N 1220 -690 1220 -650 {lab=#net1}
N 1220 -730 1220 -700 {lab=#net1}
N 1220 -700 1220 -690 {lab=#net1}
N 1020 -490 1090 -490 {lab=Vo}
N 1060 -490 1090 -490 {lab=Vo}
N 1060 -520 1060 -490 {lab=Vo}
N 1020 -420 1090 -420 {lab=VSS}
N 1050 -420 1050 -390 {lab=VSS}
N 1000 -600 1020 -600 {lab=Vo}
N 470 -680 470 -640 {lab=Vo}
N 470 -570 470 -510 {lab=Vin}
N 1480 -820 1480 -780 {lab=VDD_1V8}
N 1480 -720 1480 -660 {lab=Vref}
N 1480 -660 1520 -660 {lab=Vref}
N 1480 -660 1480 -580 {lab=Vref}
N 1370 -630 1520 -630 {lab=I_PTAT}
N 1370 -660 1370 -630 {lab=I_PTAT}
N 1370 -630 1370 -490 {lab=I_PTAT}
N 1310 -520 1310 -490 {lab=I_PTAT}
N 1310 -460 1330 -460 {lab=VSS}
N 1370 -420 1370 -390 {lab=VSS}
N 1310 -520 1360 -520 {lab=I_PTAT}
N 1480 -520 1480 -390 {lab=VSS}
N 1420 -390 1480 -390 {lab=VSS}
N 1480 -390 1590 -390 {lab=VSS}
N 1590 -590 1590 -390 {lab=VSS}
N 1590 -820 1590 -700 {lab=VDD_1V8}
N 1670 -640 1710 -640 {lab=OUT}
N 1370 -820 1590 -820 {lab=VDD_1V8}
N 560 -340 1590 -340 {lab=RST}
N 1370 -390 1420 -390 {lab=VSS}
N 1250 -460 1270 -460 {lab=RST}
N 1250 -460 1250 -340 {lab=RST}
N 1220 -390 1370 -390 {lab=VSS}
N 1310 -430 1310 -390 {lab=VSS}
N 1330 -460 1330 -410 {lab=VSS}
N 1310 -410 1330 -410 {lab=VSS}
N 1360 -520 1370 -520 {lab=I_PTAT}
C {devices/ipin.sym} 560 -820 0 0 {name=p4 lab=VDD_1V8
}
C {JNW_ATR_SKY130A/JNWATR_PCH_4C5F0.sym} 670 -750 0 1 {name=x6}
C {JNW_ATR_SKY130A/JNWATR_PCH_4C5F0.sym} 710 -750 0 0 {name=x9}
C {sky130_fd_pr/pnp_05v5.sym} 650 -450 0 1 {name=Q3
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 750 -580 3 1 {name=x10 }
C {sky130_fd_pr/pnp_05v5.sym} 730 -450 0 0 {name=Q4
model=pnp_05v5_W3p40L3p40
m=5
spiceprefix=X
}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 1020 -430 0 1 {name=x2 }
C {JNW_ATR_SKY130A/JNWATR_NCH_8C5F0.sym} 1180 -520 0 0 {name=x12}
C {JNW_ATR_SKY130A/JNWATR_PCH_4C5F0.sym} 1180 -750 0 0 {name=x13}
C {JNW_ATR_SKY130A/JNWATR_PCH_4C5F0.sym} 1330 -750 0 0 {name=x4}
C {devices/ipin.sym} 560 -390 0 0 {name=p7 lab=VSS}
C {devices/lab_wire.sym} 840 -620 0 0 {name=p8 sig_type=std_logic lab=Vin}
C {devices/lab_wire.sym} 750 -590 0 0 {name=p9 sig_type=std_logic lab=VD1_out
}
C {devices/lab_wire.sym} 1020 -600 0 0 {name=p10 sig_type=std_logic lab=Vo}
C {devices/lab_wire.sym} 750 -490 0 0 {name=p11 sig_type=std_logic lab=VD2_out

}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 1090 -430 0 0 {name=x3 }
C {JNW_GR04_SKY130A/Opamp_test.sym} 920 -600 0 0 {name=x1}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 470 -580 0 0 {name=x5 }
C {devices/lab_wire.sym} 470 -670 0 0 {name=p1 sig_type=std_logic lab=Vo}
C {devices/lab_wire.sym} 470 -510 0 0 {name=p2 sig_type=std_logic lab=Vin}
C {devices/lab_wire.sym} 1590 -390 0 1 {name=p15 sig_type=std_logic lab=VSS
}
C {devices/res.sym} 1480 -750 0 0 {name=R3
value=8k
footprint=1206
device=resistor
m=1}
C {JNW_GR04_SKY130A/Opamp_comp.sym} 1600 -630 0 0 {name=x14}
C {devices/res.sym} 1480 -550 0 0 {name=R4
value=10k
footprint=1206
device=resistor
m=1}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 1370 -430 0 0 {name=x15 }
C {JNW_ATR_SKY130A/JNWATR_NCH_4C5F0.sym} 1270 -460 0 0 {name=x16 }
C {devices/ipin.sym} 560 -340 0 0 {name=p3 lab=RST}
C {devices/lab_wire.sym} 1480 -660 0 0 {name=p5 sig_type=std_logic lab=Vref}
C {devices/lab_wire.sym} 1370 -630 0 0 {name=p6 sig_type=std_logic lab=I_PTAT}
C {devices/opin.sym} 1710 -640 0 0 {name=p14 lab=OUT}
C {devices/lab_wire.sym} 1590 -340 0 1 {name=p12 sig_type=std_logic lab=RST
}
